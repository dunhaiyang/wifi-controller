# Keil uVision project OperationSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: OperationSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HeadFile\Arch;.\HeadFile\OS_api;.\HeadFile\KQA_OS;.\HeadFile\App_api;.\HeadFile\App\Command_Conter;.\HeadFile\App\Command_DataStructure;.\HeadFile\App\Command_Device;.\HeadFile\App\Command_Repeater;.\HeadFile\App\Command_WhiteList;.\HeadFile\App\Command_Kernel;.\HeadFile\MiddlewareBoardcast;.\HeadFile\MiddlewareMenu;.\HeadFile\MiddlewareTask;.\HeadFile\MiddlewareWireless;.\HeadFile\MiddlewareSocket;.\HeadFile\MiddlewareWesocket
  group ReadMe
    ./SourceFile/ReadMe/: ReadMe.txt
  group Arch
    ./SourceFile/Arch/: types.c Timer0.c PCA.c Uart1.c Eeprom.c SPI.c NRF905.c Uart2.c UsrC210.c Ch395Uart.c Ch395Cmd.c
  group OS_api
    ./HeadFile/OS_api/: OS_HAL.h
  group KQA_OS
    ./SourceFile/KQA_OS/: Hardware.c Led.c Beep.c Console.c Parameter.c Wireless.c Wifi.c Network.c Scheduler.c
  group App_api
    ./HeadFile/App_api/: APP_HAL.h
    ./SourceFile/App_api/: APP_HAL_API.c
  group App
    ./SourceFile/App/Command_Kernel/: Pc.c Command_Wireless.c Command_Network.c
    ./SourceFile/App/Command_DataStructure/: Command_Temporary.c Command_ControlerInfo.c Command_NormalDeviceInfo.c Commmand_SpecialDeviceInfo.c Command_HookFunction.c
    ./SourceFile/App/Command_Conter/: Command_SearchIp.c Command_NetworkParameter.c Command_ControlerTest.c Command_ControlerWorkMode.c Command_ControlerParameter.c Command_ControlerDeviceList.c Command_Heartbeat.c
    ./SourceFile/App/Command_Repeater/: Command_RepeaterTest.c Command_RepeaterParameter.c
    ./SourceFile/App/Command_Device/: Command_DeviceTest.c Command_DevicePool.c Command_OneCardDataUpload.c Command_OneCardOperation.c Command_OneCardDataUploadDelete.c Command_ReadOneOfflineData.c Command_DeleteSomeAreaData.c Command_DeleteOneOfflineData.c Command_ChangeDeviceSerialNo.c Command_ReadAllTradeRecord.c Command_RealtimeControl.c Command_SerialNoWatchAndConfigure.c Command_ReadWriteConfigureParameter.c Command_RestoreDataStructure.c Command_RestoreDefaultConfigure.c Command_ReadWhiteListPointer.c Command_ReadWhiteList.c Command_ProgramUpdate.c
    ./SourceFile/App/Command_WhiteList/: Command_WhiteListInit.c Command_WhiteListUpload.c
  group MiddlewareMenu
    ./SourceFile/MiddlewareMenu/: Middleware_Menu.c
  group MiddlewareTask
    ./SourceFile/MiddlewareTask/: Middleware_Task.c
  group MiddlewareWireless
    ./SourceFile/MiddlewareWireless/: Middleware_Wireless.c
  group MiddlewareBoardcast
    ./SourceFile/MiddlewareBoardcast/: Middleware_Boardcast.c
  group MiddlewareSocket
    ./SourceFile/MiddlewareSocket/: Middleware_Socket.c
  group Init
    ./SourceFile/Init/: main.c
